# Keil uVision project Sample01.uvprojx, settings and files
target Sample01 (ARM-ADS)
  device: STM32F205RGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Sample01
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER DEBUG EMW3162
  c include: ..\..\..\include;..\..\..\MICO;..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\inc;..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\CMSIS;..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver;..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv;..\..\..\Platform\Common\Cortex-M3\STM32F2xx;..\..\..\Platform\EMW3162;..\..\..\Demos\Sample01;..\..\..\Library\support;..\..\..\Platform\include;..\..\..\Platform\Common\Cortex-M3\;..\..\..\External
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0xf4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_warning 6654 --diag_warning 6238
  group Application
    ../../../Demos/Sample01/: AppEntrance.c
  group startup
    ../../../Platform/IDEs/Keil/: startup_stm32f2xx.s patch_keil.c Retarget.c
  group platform_board
    ../../../Platform/EMW3162/: platform.c
    ../../../Platform/Common/Cortex-M3/STM32F2xx/: gpio_irq.c MicoDriverAdc.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c rtc.c stm32f2xx_platform.c usbh_conf.c
    ../../../Platform/Common/Cortex-M3/: crt0_IAR.c hardfault.c
    ../../../Platform/Common/IAR/: stdio_IAR.c
  group Mico
    ../../../MICO/: MICOEntranceT.c
  group Library
    ../../../Library/: MICOConfig.c mxchipWNet_cm3_sdio.a
  group External
    ../../../External/Curve25519/: curve25519-donna.c
    ../../../External/JSON-C/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
    ../../../External/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group platform_drivers
    ../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    ../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/: system_stm32f2xx.c
  group support
    ../../../Library/support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group EMW1062_driver
    ../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
    ../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/SDIO/: wlan_bus.c
  group dummy_1062_driver
    ../../../Platform/vendor/Sample/Sample01/EMW1062/: read_wifi_firmware.c wlan_platform.c
    ../../../Platform/vendor/Sample/Sample01/EMW1062/SDIO/: wlan_bus.c
  group BoardAP80V1
    ../../../Platform/BoardConfig/AP80V1/: platform.c
  group MV_AP80_driver
    ../../../Platform/vendor/mvsilicon/AP80A0s/driver/: driver.lib
    ../../../Platform/vendor/mvsilicon/AP80A0s/: MicoDriverAdc.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c platform_mico.c startup.c freertos.lib
target SimpleMico_AP80 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Simple01_AP80
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER DEBUG
  c include: ..\..\..\include;..\..\..\MICO;..\..\..\Demos\Sample01;..\..\..\Library\support;..\..\..\Platform\include;..\..\..\Platform\Common\Cortex-M3\;..\..\..\External;..\..\..\Platform\BoardConfig\AP80V1;..\..\..\Platform\vendor\mvsilicon\AP80A0s\driver\inc;..\..\..\Platform\vendor\mvsilicon\AP80A0s\;..\..\..\Platform\vendor\mvsilicon\AP80A0s\driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\Platform\vendor\mvsilicon\AP80A0s\MVs18.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
--diag_warning=6654,6238 --diag_suppress=L6314W,L6319W
software components: CMSIS:CORE 3.40.0
